# Keil uVision project PowerWindowController.uvproj, settings and files
target Project (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: PowerWindowController +hex
  c flags: Optim=1 wLevel=2
  c include: ./;.\os\include;.\config;.\inc;.\driverlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./app/: main.c startup_TM4C123.s
  group config
    ./config/: FreeRTOSConfig.h
  group driverlib
    ./driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group os
    ./os/: croutine.c event_groups.c list.c port.c queue.c stream_buffer.c tasks.c timers.c heap_4.c
